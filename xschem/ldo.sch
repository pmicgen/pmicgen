v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/designer/LDO_CAC/automation/xschem/bandgap_1v_v01.sym} -70 -20 0 0 {name=x1}
